# Keil uVision project BMS_V1.uvprojx, settings and files
target BMS_V1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x0000F400) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BMS_V1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\apl;..\fml;..\bsp;..\os;..\RTD\ST;..\RTD\ST\Start;..\RTD\ST\Libarary;..\os\FreeRTOS\include;..\os\FreeRTOS\portable
  memory RVCT4: ROM 0x8000000 size 0xf400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bms_main
    ../bms_main/: main.c
  group apl
    ../apl/: apl_system.c apl_cc_transport.c apl_can.c apl_debug.c apl_irq.c apl_task_protect.c apl_task_sample.c apl_task_state.c apl_task_soc.c apl_task_balance.c apl_task_can_tx.c apl_task_can_rx.c apl_rtos.c
  group fml
    ../fml/: fml_data.c fml_debug.c fml_policy.c fml_state.c fml_hw_recovery.c fml_recovery.c fml_fet_manager.c fml_health.c fml_soc.c fml_balance.c fml_can.c fml_persistence.c fml_ntc.c fml_sample.c fml_afe_startup.c fml_fault.c fml_protect.c
  group bsp
    ../bsp/: bsp_clock.c bsp_gpio.c bsp_timer.c bsp_soft_i2c.c bsp_bq76940_crc8.c bsp_exti.c bsp_iwdg.c bsp_can.c bsp_flash.c bsp_uart.c bsp_bq76940.c bsp_bq76940_measurement.c bsp_bq76940_control.c
  group os
    ../os/FreeRTOS/source/: tasks.c queue.c list.c event_groups.c timers.c stream_buffer.c croutine.c
    ../os/FreeRTOS/portable/: heap_4.c port.c
    ../os/: os_hooks.c os_runtime.c os_api.c
  group RTD
    ../RTD/ST/Libarary/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_usart.c misc.c
    ../RTD/ST/Start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
