# Keil uVision project BMS_V1.uvprojx, settings and files
target BMS_V1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x0000F400) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BMS_V1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\APL;..\..\BSP;..\..\Config;..\..\DRV\SoftI2C;..\..\DRV\BQ76940;..\..\FML\Core;..\..\FML\Data;..\..\FML\Afe;..\..\FML\Measurement;..\..\FML\Protect;..\..\FML\State;..\..\FML\Fet;..\..\FML\Recovery;..\..\FML\Health;..\..\FML\Soc;..\..\FML\Balance;..\..\FML\Communication;..\..\FML\Storage;..\..\User;..\..\..\docs\reference\ST\STM32F10x Standard Peripheral Library;..\..\..\docs\reference\ST\STM32F10x Standard Peripheral Library\Start;..\..\..\docs\reference\ST\STM32F10x Standard Peripheral Library\Libarary;..\..\..\docs\FreeRTOS\include;..\..\..\docs\FreeRTOS\portable
  memory RVCT4: ROM 0x8000000 size 0xf400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APL
    ../../User/: main.c
    ../../APL/: apl_system.c apl_fml_port.c apl_cc_transport.c apl_can.c apl_debug.c apl_irq.c
    ../../APL/Task/: apl_task_protect.c apl_task_sample.c apl_task_state.c apl_task_soc.c apl_task_balance.c apl_task_can_tx.c apl_task_can_rx.c
  group FML
    ../../FML/Data/: bms_data.c
    ../../FML/Communication/: bms_debug.c bms_can.c
    ../../Config/: bms_policy.c
    ../../FML/State/: bms_state.c
    ../../FML/Recovery/: bms_hw_recovery.c bms_recovery.c
    ../../FML/Fet/: bms_fet_manager.c
    ../../FML/Health/: bms_health.c
    ../../FML/Soc/: bms_soc.c
    ../../FML/Balance/: bms_balance.c
    ../../FML/Storage/: bms_persistence.c
    ../../FML/Measurement/: bms_ntc.c bms_sample.c
    ../../FML/Afe/: bms_afe_startup.c
    ../../FML/Core/: bms_fault.c
    ../../FML/Protect/: bms_protect.c
  group BSP_DRV
    ../../BSP/: bsp_clock.c bsp_gpio.c bsp_timer.c bsp_exti.c bsp_iwdg.c bsp_can.c bsp_flash.c bsp_uart.c
    ../../DRV/SoftI2C/: soft_i2c.c
    ../../DRV/BQ76940/: crc8_bq76940.c
  group DRV_BQ76940
    ../../DRV/BQ76940/: bq76940.c bq76940_measurement.c bq76940_control.c
  group SPL_Used_Phase2
    ../../../docs/reference/ST/STM32F10x Standard Peripheral Library/Libarary/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_usart.c misc.c
  group CMSIS_ST_Reference
    ../../../docs/reference/ST/STM32F10x Standard Peripheral Library/Start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group FreeRTOS_V11
    ../../../docs/FreeRTOS/source/: tasks.c queue.c list.c event_groups.c timers.c stream_buffer.c croutine.c
    ../../../docs/FreeRTOS/portable/: heap_4.c port.c
    ../../APL/: apl_rtos.c apl_rtos_hooks.c
